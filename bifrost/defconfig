## bifrost/defconfig
```kconfig
CONFIG_MALI_CINSTR_GWT=n
CONFIG_SYNC_FILE=y
CONFIG_MALI_TRACE_POWER_GPU_WORK_PERIOD=y 
CONFIG_MALI_NO_MALI=n
CONFIG_MALI_REAL_HW=y 
CONFIG_MALI_CSF_SUPPORT=n
```
